# IAR project Backup of uCOS-III-Ex2.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\BSP; ..\uCOS-III-Lib; ..\BSP\uCOS-III; ..\BSP\ST\STM32\inc; ..\..\..\..\..\uc-lib; ..\..\..\..\..\uC-CPU; ..\..\..\..\..\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\..\..\..\uCOS-III\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: uCOS-III-Ex2.out
  ILINK.IlinkIcfFile: ..\BSP\STM32_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: deliver.c deliver.h distanceSensor.c distanceSensor.h font.h lcd.c lcd.h lineTracker.c lineTracker.h motorMove.c motorMove.h term.h touch.c touch.h
  group APP
    ./: app.c app_vect.c includes.h os_app_hooks.c os_app_hooks.h
  group APP/CFG
    ./: app_cfg.h os_cfg_app.h stm32f10x_conf.h
  group BSP
    ../BSP/: STM32_FLASH.icf
  group BSP/Headers
    ../BSP/: bsp.h bsp_i2c.h bsp_ser.h bsp_stlm75.h
    ../BSP/uCOS-III/: bsp_os.h
  group BSP/Source
    ../BSP/: bsp.c bsp_i2c.c bsp_int.c bsp_periph.c bsp_ser.c bsp_stlm75.c
    ../BSP/uCOS-III/: bsp_os.c
  group BSP/STM32 Library/inc
    ../BSP/ST/STM32/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group BSP/STM32 Library/src
    ../BSP/ST/STM32/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CFG - LIBRARIES
    ./: cpu_cfg.h lib_cfg.h os_cfg.h os_type.h
  group uC/CPU/Headers
    ../../../../../uC-CPU/ARM-Cortex-M3/IAR/: cpu.h
    ../../../../../uC-CPU/: cpu_core.h cpu_def.h
  group uC/CPU/Source
    ../../../../../uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
    ../../../../../uC-CPU/: cpu_core.c
  group uC/LIB/Headers
    ../../../../../uC-LIB/: lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h
  group uC/LIB/Source
    ../../../../../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-III
    ../../../../../uCOS-III/Source/: os_cfg_app.c
  group uC/OS-III/Headers
    ../../../../../uCOS-III/Source/: os.h
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h
  group uC/OS-III/Source
    ../../../../../uCOS-III/Source/: os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
